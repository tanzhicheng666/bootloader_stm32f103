# Keil uVision project bootloader_app.uvprojx, settings and files
target APP (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08004800,0x0003B800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_app +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\bootloader_app.bin .\Objects\bootloader_app.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\main;..\core;..\bsp;..\common;..\sdk\CMSIS\Core\Include;..\sdk\CMSIS\Device\ST\STM32F1xx\Include;..\sdk\HAL_Driver\Inc;..\sdk\HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8004800 size 0x3b800
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../main/: main.c
  group core
    ../sdk/CMSIS/Device/ST/STM32F1xx/Source/arm/: startup_stm32f103xe.s
    ../core/: system_stm32f1xx.c stm32f1xx_it.c stm32f1xx_hal_conf.h
  group bsp
    ../bsp/: bsp_tick.c bsp_gpio.c bsp_flash.c
  group common
    ../common/: common_types.h common_defines.h
  group sdk/hal
    ../sdk/HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
