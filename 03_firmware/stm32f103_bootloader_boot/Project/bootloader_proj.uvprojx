# Keil uVision project bootloader_proj.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_proj
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\Core;..\Main;..\Bsp;..\App;..\SDK\CMSIS\Include;..\SDK\CMSIS\Device\ST\STM32F1xx\Include;..\SDK\STM32F1xx_HAL_Driver\Src;..\SDK\STM32F1xx_HAL_Driver\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Main
    ../Main/: main.c
  group Core
    ../Core/: startup_stm32f103xe.s stm32f1xx_clk.c stm32f1xx_it.c stm32f1xx_hal_conf.h system_stm32f1xx.c
  group SDK
    ../SDK/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash_ex.c
  group Bsp
    ../Bsp/: bsp_gpio.c bsp_gpio.h bsp_uart.c bsp_uart.h bsp_flash.c bsp_flash.h
  group App
    ../App/: app_button.c app_button.h app_task.c app_task.h app_communicate.c app_communicate.h
