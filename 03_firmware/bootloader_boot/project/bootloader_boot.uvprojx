# Keil uVision project bootloader_boot.uvprojx, settings and files
target Bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader_boot +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=.\Objects\bootloader_boot.bin .\Objects\bootloader_boot.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ..\main;..\core;..\bsp;..\app;..\algorithm;..\common;..\sdk\CMSIS\Core\Include;..\sdk\CMSIS\Device\ST\STM32F1xx\Include;..\sdk\HAL_Driver\Inc;..\sdk\HAL_Driver\Inc\Legacy
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ../main/: main.c
  group core
    ../sdk/CMSIS/Device/ST/STM32F1xx/Source/arm/: startup_stm32f103xe.s
    ../sdk/CMSIS/Device/ST/STM32F1xx/Source/: system_stm32f1xx.c
    ../core/: stm32f1xx_it.c stm32f1xx_hal_conf.h
  group bsp
    ../bsp/: bsp_sysclk.c bsp_tick.c bsp_gpio.c bsp_uart.c bsp_flash.c
  group algorithm
    ../algorithm/: algo_fifo.c algo_crc.c
  group app
    ../app/: app_task.c app_button.c app_comm.c app_boot.c app_cmd.c
  group common
    ../common/: common_types.h common_defines.h
  group sdk/hal
    ../sdk/HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c
  group document
    ../document/: coding_style.md file_header_format.md protocol_spec.md milestone_plan.md
